# IAR project driverlib.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LM3S101 TexasInstruments LM3S101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DRIVERLIB_APPS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\; ..\..\inc1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib-cm3.srec
  ILINK.IlinkOutputFile: driverlib-cm3.out
  group Source
    ../: adc.c aes.c arcm.c camera.c cpu.c crc.c des.c flash.c gpio.c gprcm.c hib.c hwsemaphore.c i2c.c interrupt.c mcasp.c mcspi.c pinmap.c shamd5.c systick.c timer.c uart.c udma.c utils.c wdt.c
